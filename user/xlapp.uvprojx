# Keil uVision project xlapp.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  OUTBIN\app.bin ..\OBJ\app.axf
  AfterMake: comb.bat boot.hex ..\obj\app.hex ..\obj\BootLoader-app.hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE;..\FUNCTION
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\OBJ\app.sct
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c system.c
  group HARDWARE
    ../hardware/: bsp.c timer.c ds18b20.c bsp_i2c.c rc522.c mpu6050.c ina219.c motor.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c
    ../core/: startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
    ../stm32f10x_fwlib/src/: stm32f10x_spi.c ds27xx.lib
  group README
    ../: README.TXT
  group FUNCTION
    ../function/: debug.c protocol.c myqueue.c sched.c key.c
